# Keil uVision project selftest_mpb.uvproj, settings and files
target SelfTest (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: selftest
  AfterMake: move.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M3 FPGA_IMAGE CMSDK_CM3
  c include: ..\cmsis\CMSIS\Include;..\cmsis\Device\Include;..\v2m_mps2;..\apmain;..\cmsis\Device\Include\CMSDK_CM3;.\OV5640;..\LIB_Config;..\LCD;..\SPI;..\Fonts
  scatter file: .\selftest_mpb.sct
  link misc: --entry=Reset_Handler
  group MPS2_TESTS
    ../apmain/: main.c common.c retarget.c uart_stdout.c
  group TIMER
    ../aptimer/: aptimer.c
  group SDRAM/SRAM
    ../apmem/: apmemsup.s apmem.c
  group LEDs
    ../apleds/: apleds.c
  group CLCD
    ../apclcd/: intro.c apclcd.c flyer.c
  group TSC
    ../aptsc/: aptsc.c
  group AACI
    ../apaaci/: apaaci.c
  group ETHERNET
    ../aplan/: aplan.c
  group SSP
    ../apssp/: apssp.c
  group CMSIS
    ../cmsis/Device/Source/: CMSDK_driver.c
    ../cmsis/Device/Source/CMSDK_CM3/: startup_CMSDK_CM3.s system_CMSDK_CM3.c
  group V2M_MPS2
    ../v2m_mps2/: GLCD_SPI_MPS2.c TSC_I2C_MPS2.c AAIC_I2C_MPS2.c AAIC_I2S_MPS2.c ETH_MPS2.c fpga.c led.c
  group SONAR
    ../apsonar/: apsonar.c rht03.c
  group UART
    ../apuart/: apuart.c
  group OV5640
    ./OV5640/: gpio_m3.c gpio_m3.h ov5640.c sccb.c
  group LCD
    ../LCD/: LCD.c
  group SPI
    ../SPI/: SPI_MPS2.c
  group Fonts
    ../Fonts/: Fonts.c
